# Keil uVision project Dac_SineWave.uvprojx, settings and files
target FLASH (ARM-ADS)
  device: LPC1788 NXP
  pack: Keil.LPC1700_DFP.2.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Dac_SineWave +hex
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Drivers\include;..\..\Dac_SineWave;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC177x_8x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/ARM/: startup_LPC177x_8x.s
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc177x_8x_dac.c lpc177x_8x_pinsel.c lpc177x_8x_gpdma.c lpc177x_8x_uart.c lpc177x_8x_clkpwr.c lpc177x_8x_gpio.c lpc177x_8x_timer.c
  group Main
    ../: Dac_SineWave.c
  group Readme
    ../: abstract.txt
target RAM (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Dac_SineWave +hex
  c flags: Optim=1 wLevel=2
  c define: __RAM_MODE__
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
