# Keil uVision project NXP_emWin522_LPC1788.uvprojx, settings and files
target Debug_FLASH (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1788 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MDO_EMWIN522 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --c99
  c include: .\Application;.\BoardSupport;.\Config;..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Drivers\include;..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Core\CMSIS\Include;..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Core\Device\NXP\LPC177x_8x\Include;.\Setup;.\Inc;.\GUI;.\GLCD;.\SDRAM;.\Application\Fonts;.\Application\Pics;.\Application\Dedector;.\FreeRTOS_v8.0.0;.\FreeRTOS_v8.0.0\Source\include;.\FreeRTOS_v8.0.0\Source\portable\MemMang;.\FreeRTOS_v8.0.0\Source\portable\RVDS\ARM_CM3;.\FatFS;.\USBHost;.\audio_play;.\Application\EMC_NAND;.\TouchPanel;.\Application\FieldScanner;.\Application\dsp;.\Application\SpiFlash;.\Application\SpiFlash\S25FL512S\src;.\Application\SpiFlash\S25FL512S\Hals\Generic;.\AZPlus;.\Application\FieldScanner
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x90800000
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=6329 --diag_suppress=6314 --feedback=unused.txt
  group Application
    ./Application/Dedector/: AppCommon.h AppCommon.c RuntimeLoader.c Strings.c
    ./Application/: GUIDEMO_Start.c MyMacro.h ErrorLog.c emc_nor.c AppSettings.c GuiConsole.c StatusBar.c
    ./Application/EMC_NAND/: emc_nand.c
    ./Application/Fonts/: AppFont.h
  group Config
    ./Config/: Global.h GUIConf.h SysConf.h
  group GUI
    ./GUI/: GUI.h emWin_522_Keil460_M3_LE.lib
  group Inc
    ./Inc/: BSP.h SEGGER.h
  group Setup
    ./Setup/: BSP.c GUIConf.c LCDConf.h GUI_X.c LCDConf_multiplebuffer.c
  group Doc
    ./DOCs/: DONE.txt NOTEs.txt TODO.txt
  group CMSIS_M3
    ../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Driver
    ../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Drivers/source/: debug_frmwrk.c lpc177x_8x_adc.c lpc177x_8x_clkpwr.c lpc177x_8x_exti.c lpc177x_8x_gpio.c lpc177x_8x_i2c.c lpc177x_8x_i2s.c lpc177x_8x_mci.c lpc177x_8x_pinsel.c lpc177x_8x_pwm.c lpc177x_8x_rtc.c lpc177x_8x_ssp.c lpc177x_8x_systick.c lpc177x_8x_timer.c lpc177x_8x_uart.c lpc177x_8x_emc.c lpc177x_8x_usbhost.c lpc177x_8x_gpdma.c lpc177x_8x_dac.c
  group Startup
    ../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/ARM/: startup_LPC177x_8x.s
  group GLCD
    ./GLCD/: AsciiLib.c GLCD.c
  group SDRAM
    ./SDRAM/: SDRAM_K4S561632C_32M_16BIT.c SDRAM_K4S561632C_32M_16BIT.h
  group Pics
    ./Application/Pics/: AppPics.h
  group Fonts
    ./Application/Fonts/: FontD6x8.c AppFont.h Arial24Bstd.c Arial32Bstd.c
  group Dedector
    ./Setup/: led.c
    ./Application/Dedector/: Serial.c MyCheckbox.c Communication.c UartInt.c Analog.c Popup.c Intro2.c
    ./Application/: UMDShared.h Battery.c
  group FreeRTOS_v8.0.0
    ./FreeRTOS_v8.0.0/Source/: list.c queue.c tasks.c event_groups.c timers.c
    ./FreeRTOS_v8.0.0/Source/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS_v8.0.0/Source/portable/MemMang/: heap_2.c
    ./FreeRTOS_v8.0.0/: FreeRTOSConfig.h
  group fatFS
    ./FatFS/: fs_mci.c monitor.c fatfs_main.c ff.c
    ./FatFS/option/: ccsbcs.c
  group USBHost
    ./USBHost/: usbhost_fat.c usbhost_main.c usbhost_ms.c usbhost_uart.c
  group audio_play
    ./audio_play/: wav.c ACodec.c APlay.c Dac.c
  group TouchPanel
    ./TouchPanel/: TouchPanel.c Calibrate.lib TSTask.c
  group dsp
    ./Application/: CoreFirFilter.c
    ./Application/dsp/: DiffCalculator.c
  group SpiFlash
    ./Application/SpiFlash/: FlashDriver.c SpiFlash.c
    ./Application/SpiFlash/S25FL512S/src/: slld.c
    ./Application/SpiFlash/S25FL512S/Hals/Generic/: slld_hal_example.c
    ./Application/SpiFlash/S25FL512S/TestCase/: slld_util.c
  group AZPlus
    ./AZPlus/: AZPAllMetal.c AZPDisc.c AZPFast.c AZPLoading.c AZPMenu.c
  group FS
    ./Application/FieldScanner/: ATAutoFreq.c ATBrightVol.c ATDistance.c ATLang.c ATLoading.c ATManuelFreq.c ATMenu.c ATRadar.c
target Release_FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Start_LPC1788_EA_LPC1788_KEIL_CMSIS
  c flags: Optim=4 oTime=1
  c misc: --diag_suppress=951
  c include: Application;Config;GUI;Inc;Setup
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Setup\FLASH.sct
  link misc: --diag_suppress=6329 --diag_suppress=6314
